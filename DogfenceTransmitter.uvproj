# Keil uVision project DogfenceTransmitter.uvproj, settings and files
target Application (MCS-51)
  device: STC8A8K64S4A12 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: DogfenceTransmitter +hex
  c flags: Optimize=8 SizeSpeed=1
  group Driver
    ./: STARTUP.A51 Common.c Common.h Key.c Key.h LED.c LED.h Uart1.c Uart1.h Timer.c Timer.h EEPROM.h EEPROM.c
  group User
    ./: main.c
